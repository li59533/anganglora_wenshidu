# Keil uVision project MKL16_withOSAL.uvprojx, settings and files
target Normal (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: MKL16Z64xxx4 NXP
  pack: Keil.Kinetis_KLxx_DFP.1.14.0
  cpu: IRAM(0x1FFFF800,0x00002000) IROM(0x00000000,0x00010000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: MKL16_withOSAL
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: CPU_MKL16Z64VFM4
  c include: ..\components\MKL16Z4\drivers;..\components\MKL16Z4\utilities;..\components\CMSIS\Include;..\components\MKL16Z4\arm;..\components\MKL16Z4;..\mdl\osal\src;..\mdl;..\bsp;..\task;..\fml;..\Utilities;..\app;..\mdl\osal\ports;..\mdl\rttviewer
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x1ffff800 size 0x2000
  scatter file: ..\components\MKL16Z4\arm\MKL16Z64xxx4_flash.scf
  group component/startup
    ../components/MKL16Z4/: system_MKL16Z4.c system_MKL16Z4.h
    ../components/MKL16Z4/arm/: startup_MKL16Z4.s
  group component/utilities
    ../components/MKL16Z4/utilities/: fsl_debug_console.c
  group component/dirver
    ../components/MKL16Z4/drivers/: fsl_adc16.c fsl_clock.c fsl_cmp.c fsl_common.c fsl_dac.c fsl_dma.c fsl_dmamux.c fsl_flash.c fsl_gpio.c fsl_i2c.c fsl_i2c_dma.c fsl_i2c_freertos.c fsl_llwu.c fsl_lpsci.c fsl_lpsci_dma.c fsl_lptmr.c fsl_pit.c fsl_pmc.c fsl_rcm.c fsl_rtc.c fsl_sim.c fsl_spi.c fsl_spi_dma.c fsl_spi_freertos.c fsl_tpm.c fsl_tsi_v4.c fsl_uart.c fsl_uart_dma.c fsl_uart_freertos.c fsl_smc.c
  group app
    ../app/: main.c app_battery.c app_conf.c app_getdata.c app_revmessage.c app_transfer.c
  group bsp
    ../bsp/: bsp_adc.c bsp_clock.c bsp_flash.c bsp_led.c bsp_rtc.c bsp_systick.c bsp_tim.c bsp_uart.c bsp_power.c bsp_e32.c bsp_iic.c bsp_hdc2010.c
  group fml
    ../fml/: lnprotocol.c lnprotocol_std.c system_param.c version.c
  group mdl
    ../mdl/osal/src/: osal.c osal_cfg.c osal_clock.c osal_core.c osal_msg.c osal_task.c osal_timeout.c osal_timer.c
    ../mdl/rttviewer/: clog.c SEGGER_RTT.c SEGGER_RTT_printf.c
    ../mdl/: board.c
  group task
    ../task/: hal_task.c user_task.c app_task.c net_task.c
  group utilities
    ../Utilities/: crc.c
software components: CMSIS:CORE 5.3.0, CMSIS:DSP 1.7.0
